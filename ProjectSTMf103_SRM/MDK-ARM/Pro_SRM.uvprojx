# Keil uVision project Pro_SRM.uvprojx, settings and files
target MainProject (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ObjectProject +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c misc: --C99
  c include: ..\;..\Include\incCMSIS;..\Include\incLib;..\Include\incST;..\Include\incUSB;..\Include\incUSB_User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../: main.c stm32f10x_it.c
  group StdPeriph_Driver
    ../Source/srcLib/: GPIO_STM32F10x.c misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c an_srm.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_adc.c
  group CMSIS
    ../Include/incCMSIS/: core_cm3.c
    ../: system_stm32f10x.c
  group MDK-ARM
    ../Source/srcST/: startup_stm32f10x_md.s
  group Doc
    ./: readme.txt
  group USB_User
    ../Source/srcUSB_User/: hw_config.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB_Drivers
    ../Source/srcUSB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
software components: CMSIS:CORE 5.2.0
